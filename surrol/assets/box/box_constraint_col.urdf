Commit message: save the box size in self.obj_size;

File: surrol/assets/box/box_constraint_col.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.05 0.05 0.05; visual box size=0.05 0.05 0.05
